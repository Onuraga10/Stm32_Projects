# Keil uVision project exp_uart.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F070RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: exp_uart
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PRE_INCLUDE_GLOBAL_H
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c usart.h usart.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
